require exotic-newlib/exotic-newlib-source.inc
