require exotic-newlib/exotic-newlib.inc
