require exotic-gcc/exotic-gcc-common.inc
