require exotic-newlib/exotic-newlib-common.inc
