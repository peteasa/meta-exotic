require exotic-gcc/exotic-libgcc.inc
