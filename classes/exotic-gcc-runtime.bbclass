require exotic-gcc/exotic-gcc-runtime.inc
