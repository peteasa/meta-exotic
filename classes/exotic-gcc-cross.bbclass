require exotic-gcc/exotic-gcc-cross.inc
