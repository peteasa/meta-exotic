require exotic-gcc/exotic-gcc-target.inc
