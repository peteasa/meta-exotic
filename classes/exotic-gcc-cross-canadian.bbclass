require exotic-gcc/exotic-gcc-cross-canadian.inc
