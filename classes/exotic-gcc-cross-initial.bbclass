require exotic-gcc/exotic-gcc-cross-initial.inc
