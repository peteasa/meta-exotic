require exotic-newlib/exotic-libgloss.inc
